# Keil uVision project project2.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51FA Intel
  cpu: IRAM(0-0xFF) CLOCK(20000000)
  output: project2
  c flags: Optimize=8
  group Source Group 1
    ./: STARTUP.A51 proj2.c aula3.c aula4.c
